# Keil uVision project Lab_7_AnalogClock.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32L476VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: Lab_7_AnalogClock
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: C:\Keil\ARM\CMSIS\6.2.0\CMSIS\Core\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6314W
  group Source Group 1
    ./: buzzer.c buzzer.h clock.c clock.h core_cm4_constants.s delay.c delay.h keypad.c keypad.h main.c motor.c motor.h startup_stm32l476xx.s stm32l476xx_constants.s SYSTICKs.c SYSTICKs.h
